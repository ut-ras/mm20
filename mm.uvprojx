# Keil uVision project mm.uvprojx, settings and files
target mm (ARM-GNU)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: out
  group src
    ./src/: main.c
  group libs
    ./lib/: io.c launchpad.c startup.c motors.c
  group inc
    ./inc/tivaware/: adc.h gpio.h hw_ints.h hw_memmap.h i2c.h pin_map.h pwm.h qei.h rom.h ssi.h sysctl.h systick.h timer.h uart.h
    ./inc/: launchpad.h motors.h
  group misc
    ./: .gitignore Makefile README.md
